PACKAGES:remove = "${PN}-iwlwifi-cc-a0"
PACKAGES:remove = "${PN}-iwlwifi-ty-a0"
PACKAGES:remove = "${PN}-ibt-20"
PACKAGES:remove = "${PN}-ibt-41-41"
